FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://gadgetusb.cfg \
	file://xpad-support.cfg \
"


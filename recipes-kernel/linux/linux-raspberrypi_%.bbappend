FILESEXTRAPATHS:prepend := "${THISDIR}/files/raspberrypi:"

SRC_URI += " \
	file://gadgetusb.cfg \
	file://xpad-support.cfg \
"
